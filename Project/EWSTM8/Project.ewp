# IAR project Project.ewp, settings and files
configuration STM8S903 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x300
  General.GenHeapSize: 0x300
  ICCSTM8.CCDefines: STM8S903
  ICCSTM8.CCIncludePath2: ..; ..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\Libraries\STM8S_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group StdPeriph_Drivers
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group STM8S_TouchSensing_Driver
    ../../Libraries/STM8S_TouchSensing_Driver/src/: stm8_tsl_api.c stm8_tsl_multichannelkey.c stm8_tsl_rc_acquisition.c stm8_tsl_services.c stm8_tsl_singlechannelkey.c stm8_tsl_timebase.c
  group User
    ../: main.c stm8s_it.c
  group User/Features
    ../: Beep.c FAN.c Light.c
