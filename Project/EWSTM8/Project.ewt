<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM8S903</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>StdPeriph_Drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_adc2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_awu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_tim5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_tim6.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_uart2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_uart3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_uart4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_StdPeriph_Driver\src\stm8s_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>STM8S_TouchSensing_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_TouchSensing_Driver\src\stm8_tsl_api.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_TouchSensing_Driver\src\stm8_tsl_multichannelkey.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_TouchSensing_Driver\src\stm8_tsl_rc_acquisition.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_TouchSensing_Driver\src\stm8_tsl_services.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_TouchSensing_Driver\src\stm8_tsl_singlechannelkey.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM8S_TouchSensing_Driver\src\stm8_tsl_timebase.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>Features</name>
      <file>
        <name>$PROJ_DIR$\..\Beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FAN.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Light.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm8s_it.c</name>
    </file>
  </group>
</project>


